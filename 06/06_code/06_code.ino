/*
 * SP/06 - 정규 속도 단계별 상승 실험
 * Board: Arduino Uno
 * Connection: D8 ──── D0 (Loopback)
 * 
 * 표준 보드레이트를 순차적으로 테스트
 * 각 속도에서 성공률과 비트폭 측정
 * 
 * Baud Rates: 1200, 2400, 4800, 9600, 19200, 38400, 57600, 115200
 */

#define TX_BIT 0  // D8 = PORTB0

#define TX_HIGH() (PORTB |= (1 << TX_BIT))
#define TX_LOW()  (PORTB &= ~(1 << TX_BIT))

// 테스트할 보드레이트 배열
long baudRates[] = {1200, 2400, 4800, 9600, 19200, 38400, 57600, 115200};
int numRates = 8;
int currentRateIndex = 0;

// 테스트 문자
char testChars[] = {'a', 'A', '0', '9', '!'};
int numTestChars = 5;

// 각 보드레이트별 통계
struct BaudStats {
  long baudRate;
  unsigned long bitDelay;
  int totalTests;
  int successCount;
  int errorCount;
  float successRate;
  unsigned long avgTransmitTime;
};

BaudStats stats[8];

void setup() {
  // D8 출력 설정
  DDRB |= (1 << TX_BIT);
  TX_HIGH();
  
  // 초기 UART (9600으로 시작)
  Serial.begin(9600);
  
  Serial.println("========================================");
  Serial.println(" SP/06 - Baud Rate Stepping Test");
  Serial.println("========================================");
  Serial.println("Connection: D8 ──── D0");
  Serial.println();
  Serial.println("Testing Baud Rates:");
  for (int i = 0; i < numRates; i++) {
    Serial.print("  ");
    Serial.print(baudRates[i]);
    Serial.print(" bps (bit width: ");
    Serial.print(1000000.0 / baudRates[i], 2);
    Serial.println(" us)");
  }
  Serial.println("========================================");
  Serial.println();
  Serial.println("Starting in 3 seconds...");
  
  delay(3000);  // 3초 후 자동 시작
  
  Serial.println("\nStarting tests...\n");
  delay(1000);
}

void sendByteBitBang(char c, unsigned long bitDelay) {
  unsigned long startTime = micros();
  
  // Start bit
  TX_LOW();
  delayMicroseconds(bitDelay);
  
  // Data bits (LSB first)
  for (int i = 0; i < 8; i++) {
    if ((c >> i) & 0x01) {
      TX_HIGH();
    } else {
      TX_LOW();
    }
    delayMicroseconds(bitDelay);
  }
  
  // Stop bit
  TX_HIGH();
  delayMicroseconds(bitDelay);
  
  return;
}

void testBaudRate(long baudRate, int testIndex) {
  Serial.println("========================================");
  Serial.print("TEST #");
  Serial.print(testIndex + 1);
  Serial.print(": ");
  Serial.print(baudRate);
  Serial.println(" bps");
  Serial.println("========================================");
  
  unsigned long bitDelay = 1000000 / baudRate;
  
  Serial.print("Bit Width (Theory): ");
  Serial.print(1000000.0 / baudRate, 2);
  Serial.println(" us");
  Serial.print("Bit Delay: ");
  Serial.print(bitDelay);
  Serial.println(" us");
  Serial.println();
  
  // Serial 포트를 새 보드레이트로 재설정
  Serial.end();
  delay(100);
  Serial.begin(baudRate);
  delay(100);
  
  // 버퍼 비우기
  while (Serial.available() > 0) {
    Serial.read();
  }
  
  int testSuccess = 0;
  int testErrors = 0;
  
  // 각 문자 테스트 (5개 문자 × 3회 = 15회)
  for (int repeat = 0; repeat < 3; repeat++) {
    for (int i = 0; i < numTestChars; i++) {
      char testChar = testChars[i];
      
      // 전송
      sendByteBitBang(testChar, bitDelay);
      
      // 수신 대기
      unsigned long timeout = millis() + 100;
      while (Serial.available() == 0 && millis() < timeout) {
        delayMicroseconds(10);
      }
      
      // 수신 확인
      if (Serial.available() > 0) {
        char received = Serial.read();
        if (received == testChar) {
          testSuccess++;
        } else {
          testErrors++;
        }
      } else {
        testErrors++;
      }
      
      delay(20);  // 다음 문자 전 대기
    }
  }
  
  // 통계 저장
  stats[testIndex].baudRate = baudRate;
  stats[testIndex].bitDelay = bitDelay;
  stats[testIndex].totalTests = testSuccess + testErrors;
  stats[testIndex].successCount = testSuccess;
  stats[testIndex].errorCount = testErrors;
  stats[testIndex].successRate = (testSuccess * 100.0) / (testSuccess + testErrors);
  
  // 결과 출력을 위해 9600으로 다시 변경
  Serial.end();
  delay(100);
  Serial.begin(9600);
  delay(100);
  
  // 결과 출력
  Serial.println("----------------------------------------");
  Serial.println("Results:");
  Serial.print("  Total Tests: ");
  Serial.println(testSuccess + testErrors);
  Serial.print("  Success: ");
  Serial.print(testSuccess);
  Serial.print(" (");
  Serial.print((testSuccess * 100.0) / (testSuccess + testErrors), 1);
  Serial.println("%)");
  Serial.print("  Errors: ");
  Serial.print(testErrors);
  Serial.print(" (");
  Serial.print((testErrors * 100.0) / (testSuccess + testErrors), 1);
  Serial.println("%)");
  Serial.println("========================================");
  Serial.println();
  
  delay(2000);
}

void printFinalSummary() {
  Serial.println("\n\n");
  Serial.println("########################################");
  Serial.println("#         FINAL SUMMARY TABLE          #");
  Serial.println("########################################");
  Serial.println();
  Serial.println("Baud Rate | Bit Width | Tests | Success | Errors | Rate");
  Serial.println("----------|-----------|-------|---------|--------|-------");
  
  for (int i = 0; i < numRates; i++) {
    // Baud Rate
    if (baudRates[i] < 10000) Serial.print(" ");
    if (baudRates[i] < 100000) Serial.print(" ");
    Serial.print(baudRates[i]);
    Serial.print(" | ");
    
    // Bit Width
    float bitWidth = 1000000.0 / baudRates[i];
    if (bitWidth < 100) Serial.print(" ");
    if (bitWidth < 10) Serial.print(" ");
    Serial.print(bitWidth, 2);
    Serial.print(" us | ");
    
    // Tests
    if (stats[i].totalTests < 10) Serial.print(" ");
    Serial.print(stats[i].totalTests);
    Serial.print("    | ");
    
    // Success
    if (stats[i].successCount < 10) Serial.print(" ");
    Serial.print(stats[i].successCount);
    Serial.print("      | ");
    
    // Errors
    if (stats[i].errorCount < 10) Serial.print(" ");
    Serial.print(stats[i].errorCount);
    Serial.print("     | ");
    
    // Rate
    if (stats[i].successRate < 100) Serial.print(" ");
    Serial.print(stats[i].successRate, 1);
    Serial.println("%");
  }
  
  Serial.println("########################################");
  Serial.println();
  Serial.println("CSV Format (for data analysis):");
  Serial.println("baud_rate,bit_width_us,total_tests,success,errors,success_rate");
  
  for (int i = 0; i < numRates; i++) {
    Serial.print(stats[i].baudRate);
    Serial.print(",");
    Serial.print(1000000.0 / stats[i].baudRate, 2);
    Serial.print(",");
    Serial.print(stats[i].totalTests);
    Serial.print(",");
    Serial.print(stats[i].successCount);
    Serial.print(",");
    Serial.print(stats[i].errorCount);
    Serial.print(",");
    Serial.println(stats[i].successRate, 2);
  }
  
  Serial.println("\nTest Complete!");
}

void loop() {
  if (currentRateIndex < numRates) {
    testBaudRate(baudRates[currentRateIndex], currentRateIndex);
    currentRateIndex++;
  } else {
    // 모든 테스트 완료
    printFinalSummary();
    
    // 무한 대기
    while (true) {
      delay(1000);
    }
  }
}


//========================================
// SP/06 - Baud Rate Stepping Test
//========================================
//Connection: D8 ──── D0
//
//Testing Baud Rates:
//  1200 bps (bit width: 833.33 us)
//  2400 bps (bit width: 416.67 us)
//  4800 bps (bit width: 208.33 us)
//  9600 bps (bit width: 104.17 us)
//  19200 bps (bit width: 52.08 us)
//  38400 bps (bit width: 26.04 us)
//  57600 bps (bit width: 17.36 us)
//  115200 bps (bit width: 8.68 us)
//========================================
//
//Starting in 3 seconds...
//
//Starting tests...
//
//========================================
//TEST #1: 1200 bps
//========================================
//Bit Width (Theory): 833.33 us
//Bit Delay: 833 us
//
//----------------------------------------
//Results:
//  Total Tests: 15
//  Success: 15 (100.0%)
//  Errors: 0 (0.0%)
//========================================
//
//========================================
//TEST #2: 2400 bps
//========================================
//Bit Width (Theory): 416.67 us
//Bit Delay: 416 us
//
//----------------------------------------
//Results:
//  Total Tests: 15
//  Success: 15 (100.0%)
//  Errors: 0 (0.0%)
//========================================
//
//========================================
//TEST #3: 4800 bps
//========================================
//Bit Width (Theory): 208.33 us
//Bit Delay: 208 us
//
//----------------------------------------
//Results:
//  Total Tests: 15
//  Success: 15 (100.0%)
//  Errors: 0 (0.0%)
//========================================
//
//========================================
//TEST #4: 9600 bps
//========================================
//Bit Width (Theory): 104.17 us
//Bit Delay: 104 us
//
//----------------------------------------
//Results:
//  Total Tests: 15
//  Success: 15 (100.0%)
//  Errors: 0 (0.0%)
//========================================
//
//========================================
//TEST #5: 19200 bps
//========================================
//Bit Width (Theory): 52.08 us
//Bit Delay: 52 us
//
//----------------------------------------
//Results:
//  Total Tests: 15
//  Success: 15 (100.0%)
//  Errors: 0 (0.0%)
//========================================
//
//========================================
//TEST #6: 38400 bps
//========================================
//Bit Width (Theory): 26.04 us
//Bit Delay: 26 us
//
//----------------------------------------
//Results:
//  Total Tests: 15
//  Success: 12 (80.0%)
//  Errors: 3 (20.0%)
//========================================
//
//========================================
//TEST #7: 57600 bps
//========================================
//Bit Width (Theory): 17.36 us
//Bit Delay: 17 us
//
//----------------------------------------
//Results:
//  Total Tests: 15
//  Success: 0 (0.0%)
//  Errors: 15 (100.0%)
//========================================
//
//========================================
//TEST #8: 115200 bps
//========================================
//Bit Width (Theory): 8.68 us
//Bit Delay: 8 us
//
//----------------------------------------
//Results:
//  Total Tests: 15
//  Success: 0 (0.0%)
//  Errors: 15 (100.0%)
//========================================
//
//
//
//
//########################################
//#         FINAL SUMMARY TABLE          #
//########################################
//
//Baud Rate | Bit Width | Tests | Success | Errors | Rate
//----------|-----------|-------|---------|--------|-------
//  1200 | 833.33 us | 15    | 15      |  0     | 100.0%
//  2400 | 416.67 us | 15    | 15      |  0     | 100.0%
//  4800 | 208.33 us | 15    | 15      |  0     | 100.0%
//  9600 | 104.17 us | 15    | 15      |  0     | 100.0%
// 19200 |  52.08 us | 15    | 15      |  0     | 100.0%
// 38400 |  26.04 us | 15    | 12      |  3     |  80.0%
// 57600 |  17.36 us | 15    |  0      | 15     |  0.0%
//115200 |   8.68 us | 15    |  0      | 15     |  0.0%
//########################################
//
//CSV Format (for data analysis):
//baud_rate,bit_width_us,total_tests,success,errors,success_rate
//1200,833.33,15,15,0,100.00
//2400,416.67,15,15,0,100.00
//4800,208.33,15,15,0,100.00
//9600,104.17,15,15,0,100.00
//19200,52.08,15,15,0,100.00
//38400,26.04,15,12,3,80.00
//57600,17.36,15,0,15,0.00
//115200,8.68,15,0,15,0.00
//
//Test Complete!

/*
 * SP/04 - 루프백 검증 (TX→RX Echo)
 * Board: Arduino Uno
 * Connection: D8 ──── D0 (Loopback)
 * 
 * D8(Software TX)에서 보낸 데이터를
 * D0(Hardware RX)에서 수신 후
 * D1(Hardware TX)로 USB Serial 출력
 * 
 * Baud Rate: 9600 bps
 */

#define TX_BIT 0  // D8 = PORTB0
#define BAUD_RATE 9600
#define BIT_DELAY (1000000 / BAUD_RATE)

#define TX_HIGH() (PORTB |= (1 << TX_BIT))
#define TX_LOW()  (PORTB &= ~(1 << TX_BIT))

unsigned long testCount = 0;
unsigned long successCount = 0;
unsigned long errorCount = 0;

void setup() {
  // D8(Software TX) 출력 설정
  DDRB |= (1 << TX_BIT);
  TX_HIGH();
  
  // Hardware UART 초기화
  Serial.begin(9600);
  
  // 시작 메시지
  Serial.println("========================================");
  Serial.println("  SP/04 - Loopback Verification Test");
  Serial.println("========================================");
  Serial.println("Connection: D8 ──── D0 (Jumper Wire)");
  Serial.println("Baud Rate: 9600 bps");
  Serial.println();
  Serial.println("Sending characters via D8...");
  Serial.println("Receiving via D0...");
  Serial.println("Echoing to Serial Monitor...");
  Serial.println("----------------------------------------");
  Serial.println();
  
  delay(2000);
}

void sendByteBitBang(char c) {
  // Start bit
  TX_LOW();
  delayMicroseconds(BIT_DELAY);
  
  // Data bits (LSB first)
  for (int i = 0; i < 8; i++) {
    if ((c >> i) & 0x01) {
      TX_HIGH();
    } else {
      TX_LOW();
    }
    delayMicroseconds(BIT_DELAY);
  }
  
  // Stop bit
  TX_HIGH();
  delayMicroseconds(BIT_DELAY);
}

void loop() {
  testCount++;
  char testChar = 'a';
  
  // 테스트 시작 표시
  Serial.print("[Test #");
  Serial.print(testCount);
  Serial.print("] Sending: '");
  Serial.print(testChar);
  Serial.print("' (0x");
  Serial.print((int)testChar, HEX);
  Serial.print(") → ");
  
  // D8으로 전송 (Software UART)
  sendByteBitBang(testChar);
  
  // 수신 대기 (약간의 여유 시간)
  delay(50);
  
  // D0에서 수신 확인
  if (Serial.available() > 0) {
    char received = Serial.read();
    
    // 수신 결과 출력
    Serial.print("Received: '");
    Serial.print(received);
    Serial.print("' (0x");
    Serial.print((int)received, HEX);
    Serial.print(") → ");
    
    // 송수신 일치 확인
    if (received == testChar) {
      Serial.println("✓ OK");
      successCount++;
    } else {
      Serial.println("✗ ERROR!");
      errorCount++;
    }
  } else {
    Serial.println("✗ NO DATA RECEIVED!");
    errorCount++;
  }
  
  // 통계 출력 (10번마다)
  if (testCount % 10 == 0) {
    Serial.println();
    Serial.println("----------------------------------------");
    Serial.print("Total Tests: ");
    Serial.println(testCount);
    Serial.print("Success: ");
    Serial.print(successCount);
    Serial.print(" (");
    Serial.print((successCount * 100.0) / testCount, 1);
    Serial.println("%)");
    Serial.print("Errors: ");
    Serial.print(errorCount);
    Serial.print(" (");
    Serial.print((errorCount * 100.0) / testCount, 1);
    Serial.println("%)");
    Serial.println("----------------------------------------");
    Serial.println();
  }
  
  delay(1000);  // 1초 간격
}


//
//                                                                                                                                                       ========================================
//  SP/04 - Loopback Verification Test
//========================================
//Connection: D8 ──── D0 (Jumper Wire)
//Baud Rate: 9600 bps
//
//Sending characters via D8...
//Receiving via D0...
//Echoing to Serial Monitor...
//----------------------------------------
//
//[Test #1] Sending: 'a' (0x61) → Received: 'a' (0x61) → ✓ OK
//[Test #2] Sending: 'a' (0x61) → Received: 'a' (0x61) → ✓ OK
//[Test #3] Sending: 'a' (0x61) → Received: 'a' (0x61) → ✓ OK
//[Test #4] Sending: 'a' (0x61) → Received: 'a' (0x61) → ✓ OK
//[Test #5] Sending: 'a' (0x61) → Received: 'a' (0x61) → ✓ OK
//[Test #6] Sending: 'a' (0x61) → Received: 'a' (0x61) → ✓ OK
//[Test #7] Sending: 'a' (0x61) → Received: 'a' (0x61) → ✓ OK
//[Test #8] Sending: 'a' (0x61) → Received: 'a' (0x61) → ✓ OK
//[Test #9] Sending: 'a' (0x61) → Received: 'a' (0x61) → ✓ OK
//[Test #10] Sending: 'a' (0x61) → Received: 'a' (0x61) → ✓ OK
//
//----------------------------------------
//Total Tests: 10
//Success: 10 (100.0%)
//Errors: 0 (0.0%)
